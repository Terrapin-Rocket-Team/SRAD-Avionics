File: Spaceport/PCBs/flight-computer/flight-computer/ESP32.kicad_sch (KiCad schematic)
At the start: 1 part

Commit message: Added SD Card and ESP32 UART
Parts:
- renumbered U to U?
Changed lines of the file:
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@@
 		(dnp no)
 		(fields_autoplaced yes)
-		(property "Reference" "U"
+		(property "Reference" "U?"
 			(at 147.32 49.53 0)
 			(effects
@@
 		(instances
 			(project "flight-computer"
-				(path "/b419aaf0-5349-42bc-a414-d94cafbe45e9/551958d2-abef-4077-bb30-14cb500b1ed6"
-					(reference "U8")
+				(path "/b419aaf0-5349-42bc-a414-d94cafbe45e9/cb89a847-e69c-468f-9129-87ce7a9bc840"
+					(reference "U?")
 					(unit 1)
 				)

Commit message: added external I2C, SPI, SWD, UART connectors, cleaned up schematics, and changed STM32 schematic for one with power pins. Need to add decoupling capacitors for STM32, external clock for STM32
Connections:
- net ESP_RX: now reaches U?.36 (RXD0)
- net ESP_TX: now reaches U?.37 (TXD0)
Changed lines of the file:
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@@
 	(generator_version "9.0")
 	(paper "A4")
+	(global_label "ESP_RX"
+		(shape input)
+		(at 132.08 64.77 180)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify right)
+		)
+		(property "Intersheetrefs" "${INTERSHEET_REFS}"
+			(at 122.0192 64.77 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+				(hide yes)
+			)
+		)
+	)
+	(global_label "ESP_TX"
+		(shape input)
+		(at 132.08 67.31 180)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify right)
+		)
+		(property "Intersheetrefs" "${INTERSHEET_REFS}"
+			(at 122.3216 67.31 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+				(hide yes)
+			)
+		)
+	)
 	(symbol
 		(lib_id "SRAD-Avionics:ESP32-S3-WROOM-1-N4")

Commit message: Added LEDS, Buzzer, Oscillator, decoupling capacitors, fixed 3.3 volt netclasses, reorganized main schematic page, added some annotations
Connections:
- net GND: now reaches U?.1 (GND)
- net GND: now also U?.40 (GND__1), U?.41_1 (GND__2), U?.41_2 (GND__3), U?.41_3 (GND__4), U?.41_4 (GND__5), U?.41_5 (GND__6), U?.41_6 (GND__7), U?.41_7 (GND__8), U?.41_8 (GND__9), U?.41_9 (GND__10)
- net +3V3: now reaches U?.2 (3V3)
- no-connect marks 0 -> 34

Commit message: swich ESP32 to for ESP32-S3-MINI because that is the on we are ordeirng
Parts:
- removed U?: ESP32-S3-WROOM-1-N4, ESP32-S3-WROOM-1-N4:XCVR_ESP32-S3-WROOM-1-N4, symbol SRAD-Avionics:ESP32-S3-WROOM-1-N4
- added U9: ESP32-S3-MINI-1-N4R2, ESP32-S3-MINI-1-N4R2:XCVR_ESP32-S3-MINI-1-N4R2, symbol SRAD-Avionics:ESP32-S3-MINI-1-N4R2
Connections:
- net +3V3: now also U9.3 (3V3), U9.45 (EN)
- net ESP_RX: now also U9.40 (RXD0)
- net ESP_TX: now also U9.39 (TXD0)
- net GND: now also U9.1 (GND), U9.2 (GND__1), U9.42 (GND__2), U9.43 (GND__3), U9.46 (GND__4), U9.47 (GND__5), U9.48 (GND__6), U9.49 (GND__7), U9.50 (GND__8), U9.51 (GND__9), U9.52 (GND__10), U9.53 (GND__11)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
- no-connect marks 34 -> 37

Commit message: push for schematic review
Connections:
- net +3V3 renamed +3V3A
Changed lines of the file:
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@@
 			)
 		)
-		(property "Value" "+3V3"
+		(property "Value" "+3V3A"
 			(at 156.21 36.8299 0)
 			(effects

Commit message: removed SdCard
Parts:
- added J6: UART, symbol Connector_Generic:Conn_01x06
- added R19: 10k, symbol Device:R
Connections:
- net +3V3A: now also J6.1 (Pin_1), R19.1; no longer U9.45 (EN)
- net ESP_RX: now also J6.4 (Pin_4)
- net ESP_TX: now also J6.3 (Pin_3)
- net GND: now also J6.6 (Pin_6)
- net IO0: now reaches U9.4 (IO0)
- net IO0: now also J6.2 (Pin_2)
- new net EN: J6.5 (Pin_5), R19.2, U9.45 (EN)
- no-connect marks 37 -> 36
Other:
- note added: "Small pitch dupont"

Commit message: added footprints and fixed 3.3v/gnd connector orientation
Parts:
- J6: footprint (none) -> Connector_JST:JST_XH_B6B-XH-A_1x04_P2.50mm_Vertical
- R19: footprint (none) -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
Changed lines of the file:
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@@
-	)
-	(junction
-		(at 152.4 38.1)
-		(diameter 0)
-		(color 0 0 0 0)
 	)
 	(junction
@@
 	)
 	(junction
+		(at 146.05 27.94)
+		(diameter 0)
+		(color 0 0 0 0)
+	)
+	(junction
 		(at 151.13 162.56)
 		(diameter 0)
@@
 	(wire
 		(pts
+			(xy 186.69 57.15) (xy 189.23 57.15)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 151.13 127) (xy 151.13 129.54)
 		)
@@
 	(wire
 		(pts
-			(xy 118.11 27.94) (xy 152.4 27.94)
+			(xy 118.11 27.94) (xy 146.05 27.94)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 153.67 38.1) (xy 152.4 38.1)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 151.13 111.76) (xy 151.13 114.3)
 		)
@@
 		(pts
 			(xy 151.13 114.3) (xy 151.13 116.84)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
+			(xy 146.05 27.94) (xy 152.4 27.94)
 		)
 		(stroke
@@
 	(symbol
 		(lib_id "power:+3V3")
-		(at 153.67 38.1 270)
+		(at 146.05 27.94 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(dnp no)
 		(property "Reference" "#PWR050"
-			(at 149.86 38.1 0)
+			(at 146.05 31.75 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "+3V3A"
-			(at 152.908 36.068 90)
+			(at 143.002 23.622 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" ""
-			(at 153.67 38.1 0)
+			(at 146.05 27.94 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" ""
-			(at 153.67 38.1 0)
+			(at 146.05 27.94 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Power symbol creates a global label with name \"+3V3\""
-			(at 153.67 38.1 0)
+			(at 146.05 27.94 0)
 			(effects
 				(font
@@
 			)
 		)
-		(property "Footprint" ""
+		(property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder"
 			(at 116.332 38.1 90)
 			(effects
@@
 			)
 		)
-		(property "Footprint" ""
+		(property "Footprint" "Connector_JST:JST_XH_B6B-XH-A_1x04_P2.50mm_Vertical"
 			(at 181.61 49.53 0)
 			(effects
@@
 	(symbol
 		(lib_id "power:GND")
-		(at 186.69 57.15 90)
+		(at 189.23 57.15 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(fields_autoplaced yes)
 		(property "Reference" "#PWR099"
-			(at 193.04 57.15 0)
+			(at 189.23 63.5 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "GND"
-			(at 190.5 57.1499 90)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(justify right)
+			(at 191.77 58.4199 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left)
 			)
 		)
 		(property "Footprint" ""
-			(at 186.69 57.15 0)
+			(at 189.23 57.15 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" ""
-			(at 186.69 57.15 0)
+			(at 189.23 57.15 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Power symbol creates a global label with name \"GND\" , ground"
-			(at 186.69 57.15 0)
+			(at 189.23 57.15 0)
 			(effects
 				(font
@@
 	(symbol
 		(lib_id "power:GND")
-		(at 157.48 177.8 90)
+		(at 157.48 177.8 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(on_board yes)
 		(dnp no)
-		(fields_autoplaced yes)
 		(property "Reference" "#PWR051"
-			(at 163.83 177.8 0)
+			(at 157.48 184.15 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "GND"
-			(at 161.29 177.7999 90)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(justify right)
+			(at 155.702 182.1179 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left)
 			)
 		)
@@
 	(symbol
 		(lib_id "power:+3V3")
-		(at 187.96 44.45 270)
+		(at 187.96 44.45 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(dnp no)
 		(property "Reference" "#PWR096"
-			(at 184.15 44.45 0)
+			(at 187.96 48.26 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "+3V3A"
-			(at 187.96 41.91 90)
-			(effects
-				(font
+			(at 184.912 40.386 0)
+			(effects
+				(font
