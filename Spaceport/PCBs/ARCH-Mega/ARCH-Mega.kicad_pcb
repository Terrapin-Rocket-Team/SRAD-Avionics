# Repository Terrapin-Rocket-Team/SRAD-Avionics (continued)

## KiCad design Spaceport/PCBs/flight-computer/Alternate layout/flight-computer.kicad_pcb (continued)

Schematic: Barometer.kicad_sc.kicad_sch

Parts:
C1: 100 nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
U1: MS5611-01BA; LGA-8_3x5mm_P1.25mm

Connections:
+3V3A: C1.1, U1.1 (VDD), U1.2 (PS); also elsewhere on the board
/I2C1_SCL: U1.8 (SCLK); also elsewhere on the board
/I2C1_SDA: U1.7 (SDI/SDA); also elsewhere on the board
GND: C1.2, U1.3 (GND), U1.4 (CSB), U1.5 (CSB); also elsewhere on the board

Notes on the sheet:
I2C 0x76

Board: 4 copper layers, 48.4 x 61.4 mm, 99 parts (42 on the bottom side), 75 nets.

## KiCad design Spaceport/PCBs/ARCH/ARCH.kicad_pcb

Board: 4 copper layers, 65.0 x 30.0 mm, 73 parts (30 on the bottom side), 53 nets.

Parts:
5V0: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
BSTAT: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
BZ1: Buzzer; LP_Buzzer_CMT-7525-80
C1: 22uF; C_0805_2012Metric
C2, C30, C33, C36: 10uF; C_0805_2012Metric
C3, C4: 1uF; C_0805_2012Metric
C7: 4.7u; C_0805_2012Metric
C8, C9: 47pF; C_0805_2012Metric
C10: 100n; C_0805_2012Metric
C20: 220uF; CP_Radial_D5.0mm_P2.00mm
C25: 27pF; C_0603_1608Metric
C26, C31: 100nF; C_0603_1608Metric
C29: 620pF; C_0603_1608Metric
C32: 2.2uF; C_0805_2012Metric
C34: 47nF; C_0805_2012Metric
C35: 4.7uF; C_0603_1608Metric
D8: D_Schottky; Schottky_3A_DO-214AC_SMA
FB1: FerriteBead; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x05_Pin; JST_XH_S5B-XH-A_1x05_P2.50mm_Horizontal
J2: PinSocket_2x20_P2.54mm_Vertical
J4, J7: Conn_01x02; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J6: Conn_01x04_Pin; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J10: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J12: Charge; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
L1, L4: 2.2uH; IND_AMRM00101040_PUL
L2: 1uH; IND_AMRM00101040_PUL
NTF: SW_Push; SW_EVQ-P7J01P
PG: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
PS1: TPS61288LRQQR; CONV_TPS61288LRQQR
R1: 111k; R_0603_1608Metric
R2: 15k; R_0603_1608Metric
R3, R4: 100k; R_0603_1608Metric
R5, R8, R11, R15, R16, R17, R18, R19, R20, R21, R22, R23: 2k; R_0603_1608Metric
R6: 225; R_0603_1608Metric
R7: 160; R_0603_1608Metric
R9, R10: 5.1k; R_0402_1005Metric
R12, R13: 27; R_0805_2012Metric
R14: 28.7k; R_0603_1608Metric
STAT1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1, U2: 74AUP1G80; SN74AUP1G80DRYR
U3: TLV77033PDQNR
U4: FT234XD
U5: USBLC6-2P6
U8: QFN50P400X400X100-25N; BQ25606RGER
VBus: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
WIFI: SW_Push; SW_EVQ-P7J01P

Connections:
+5V: 5V0.2 (A), C1.1, C20.1, C26.1, J2.2 (5V), J2.4 (5V), J6.1, L4.2
BAT_PG1: PG.1 (K), U8.7 (~PG)
BSTAT1: BSTAT.1 (K), U8.5 (STAT)
BTST: C34.1, U8.21 (BTST)
D+: C8.2, R12.2, U5.6 (I/O1)
D-: C9.2, R13.2, U5.4 (I/O2)
EN: PS1.6 (EN), R11.1, U1.1 (D), U1.4 (~Q)
GND: BZ1.2 (-), C1.2, C2.1, C3.2, C4.2, C7.1, C8.1, C9.1, C10.1, C20.2, C25.2, C26.2, C30.2, C32.2, C33.1, C35.2, C36.1, J1.1, J2.6 (GND), J2.9 (GND), J2.14 (GND), J2.20 (GND), J2.25 (GND), J2.30 (GND), J2.34 (GND), J2.39 (GND), J6.2, J7.2, J10.A1 (GND), J10.A12 (GND), J10.B1 (GND), J10.B12 (GND), J10.S1 (SHIELD), J12.2, PS1.3 (PGND), PS1.10 (AGND), R2.2, R4.2, R5.2, R6.1, R7.1, R9.1, R10.1, R11.2, R14.2, R15.2, R16.2, R17.2, R18.2, R21.2, R22.2, R23.2, U1.3 (GND), U2.3 (GND), U3.2 (GND), U3.5 (GND), U4.5 (GND), U4.13 (GND), U5.2 (GND), U8.6 (OTG), U8.17 (GND-1), U8.18 (GND)
IN_TG: J1.3, R22.1, U2.2 (C)
unnamed: 5V0.1 (K), R16.1
unnamed: PG.2 (A), R19.1
unnamed: BSTAT.2 (A), R20.1
unnamed: BZ1.1 (+), J2.37 (GPIO26)
unnamed: C29.2, R14.1
unnamed: C3.1, D8.1 (K), J12.1, U8.1 (VAC), U8.24 (VBUS)
unnamed: J2.1 (3.3V), NTF.2, WIFI.2
unnamed: J2.33 (GPIO13), NTF.1, R23.1
unnamed: J2.35 (GPIO19), R15.1, WIFI.1
unnamed: J4.2, J7.1
unnamed: J10.A5 (CC1), R9.2
unnamed: J10.B5 (CC2), R10.2
unnamed: J10.A6 (D+), J10.B6 (D+), U5.1 (I/O1)
unnamed: J10.A7 (D-), J10.B7 (D-), U5.3 (I/O2)
unnamed: C31.2, PS1.8 (BST)
unnamed: C29.1, PS1.2 (COMP)
unnamed: C25.1, PS1.1 (FB), R1.2, R2.1
unnamed: C31.1, L1.2, PS1.4 (SW), PS1.9 (SW__1)
unnamed: C32.1, PS1.11 (VCC)
unnamed: L4.1, PS1.5 (VOUT), R1.1
unnamed: R21.1, STAT1.1 (K)
unnamed: C4.1, U1.5 (VCC), U2.5 (VCC), U3.1 (OUT)
unnamed: C10.2, U4.2 (~RESET), U4.3 (3V3OUT), U4.9 (VCCIO)
unnamed: R13.1, U4.1 (USBDM)
unnamed: R12.1, U4.12 (USBDP)
unnamed: C7.2, FB1.1, U4.4 (VCC)
unnamed: R6.2, U8.10 (ICHG)
unnamed: R7.2, U8.8 (ILIM)
unnamed: C2.2, U8.23 (PMID)
unnamed: C34.2, L2.2, U8.19 (SW-1), U8.20 (SW)
unnamed: R3.2, R4.1, U8.11 (TS)
unnamed: R5.1, VBus.1 (K)
PWR: J1.2, R18.1, U1.2 (C)
PWR_EN: R8.2, U4.6 (CBUS0), U8.9 (~CE)
REGN: C35.1, R3.1, U8.22 (REGN)
RXD: J2.10 (RXD), J6.4, U4.7 (TXD/D0)
SCL1: J1.5, J2.5 (SCL)
SDA1: J1.4, J2.3 (SDA)
STAT1: J2.7 (GPIO4), STAT1.2 (A)
TG: J2.40 (GPIO21), R17.1, U2.1 (D), U2.4 (~Q)
TXD: J2.8 (TXD), J6.3, U4.10 (RXD/D1)
VBAT: C36.2, J4.1, U8.13 (BAT-1), U8.14 (BAT)
VBUS: D8.2 (A), FB1.2, J10.A4 (VBUS), J10.A9 (VBUS), J10.B4 (VBUS), J10.B9 (VBUS), R8.1, U5.5 (VBUS), VBus.2 (A)
VSYS: C30.1, C33.2, L1.1, L2.1, PS1.7 (VIN), R19.2, R20.2, U3.3 (EN), U3.4 (IN), U8.15 (SYS-1), U8.16 (SYS)

## KiCad design Apollo/project_folder/Jack_Yeulenski_Flight_Computer/Jack_Yeulenski_Flight_Computer.kicad_pcb

File Apollo/README.md:

# Project Apollo    

~~~
apollo.websiteURL.github.io
~~~

Welcome to the Terrapin Rocket Team (TRT). Project Apollo is a TOP SECRET mission with the goal of developing cutting edge technology for the scientific community. NASA is asking you to design a High Fidelity Data Logging Flight Computer for an L1 High Power Rocket (HFDLFCL1HPR). The instruments you will create will progress the aerospace industry and bring us closer to coninuous pressence on the Lunar surface and beyond... 

Your selection for this opportunity is a testament to your capabilities. Over the next several weeks, you will work on a multidiplinary team to research, design, test and integrate the next generation of SRAD (student researched and developed) avionics. 

## Design Requirements

Our contact at NASA Goddard Space Flight Center has requested that you make a PCB (printed circuit board) to record data during the flight of a small scale sounding rocket. NASA provided us with sensor hardware you will have to integrate. 

Sensor Hardware:
- Barometers:
    - DPS368
    - DPS310
    - MS5611
    - BMP390
    - BMP280
    
- GPS modules:
    - Sparkfun NEO-M9N-00B (SMA)
    - Sparkfun NEO-M9N-00B (chip antenna)
    - TRT proprietary GPS PCB (SMA)

PCB requirements:

- Measure alititude based on barometric pressure
- Footprint for a through-hole Teensy 4.1 microcontroller (MCU)
- Visually indicate system status on the PCB using LEDs
- Power from 4.8V battery 
- Include SMA connectivity for GPS
- I2C breakout 
- UART breakout
- SPI breakout

## Project Objectives
~~~
    1. Become familiar with the PCB schematic and layout design process
    2. Develop expertise in integrating sensor hardware with different communication protocols (I2C, UART, SPI)
    3. Create a reliable data logging program with TRT Multi Mission Flight Software (MMFS) libraries
    4. Understand what goes in to creating an embedded system 
~~~
## Development Strategy

Phase 1, Research:  
- Create a bill of materials BOM for your flight computer. This should include all components of the PCB including sensors, resistors capacitors and MCUs reguardless of whether they are present in the lab or need to be ordered.

- Read the datasheet for sensor hardware that will be integrated. Look carefully for the communication protocol the deviceswill use to communicate to other devices such as the MCU. 
    - Take note of which pins are required for that protocol for the next phase:

Phase 2, PCB Design:

- Generate a schematic in KiCad. This is a theoretical diagram that details the interconnects between devices. This is also where you will decide where to put LEDs or any other functionality to the board. 

- Assign footprints to symbols. Each symbol in the schematic will need an associated footprint. An SMD footprint is the arrangement of copper pads and outlines on a PCB designed to physically and electrically connect a surface-mount component. Unlike through-hole components, SMD parts sit directly on the board and are soldered to pads rather than inserted into drilled holes.
    - Your board will also need a footprint for a through-hole Teensy4.1 MCU. This will allow you to hand solder the MCU to your computer. 

- Complete the PCB layout and routing. This is where you will design the physical implementation of your schematic. PCB routing is the process of designing the copper traces that electrically connect components on a PCB. Layout refers to the overall arrangement of components and routing to ensure proper functionality, signal integrity, and manufacturability. 

Each sensor such as a barometer or GPS module interfaces may with the Teensy 4.1 MCU with a different communication protocol. Each protocol has its own set of rules that promote interoperability between devices in an embedded system. Start by reading the datasheet for your sensor to determine its capabilities and start to think about how you can use it for this project. 

KiCad is the primary tool you will use to generate the designs for your custom PCB. Bellow are some links to tutorials to get you started.

Board: 2 copper layers, 53.5 x 65.5 mm, 27 parts (0 on the bottom side), 16 nets.

Parts:
A1: LPS22DFTR; ST_HLGA-10_2x2mm_P0.5mm_LayoutBorder3x2y
BZ1: Buzzer; Adafruit_Buzzer
C1, C2, C4, C5: 100nF; C_0805_2012Metric
C3: 1uF; C_0805_2012Metric
D1, D2, D3: LED; LED_0805_2012Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: SW; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J2: BAT; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J3: UART Radio Connector; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J4: I2C GPS Connector; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
R1, R2, R3: 560; R_0603_1608Metric
R4: 100k; R_0603_1608Metric
R5: 78k7; R_0603_1608Metric
Rpull1, Rpull2: 5k1; R_0402_1005Metric
Teensy4.1: teensy
U1: BNO055; LGA-28_5.2x3.8mm_P0.5mm

Connections:
+3V3: A1.1 (VDD_IO), A1.6 (CS), A1.10 (VDD), C1.1, C2.2, C4.1, C5.1, D3.2 (A), J3.1, J4.1, Rpull1.2, Rpull2.2, Teensy4.1.3V (3.3V), Teensy4.1.3V1 (3.3V), U1.3 (VDD), U1.4 (NBOOT_LOAD_PIN), U1.11 (NRESET), U1.17 (COM3), U1.28 (VDDIO)
GND: A1.3 (RES), A1.5 (SDO/SA0), A1.8 (GND_IO), A1.9 (GND), BZ1.2 (-), C1.2, C2.1, C3.1, C4.2, C5.2, J2.2, J3.4, J4.4, R1.2, R2.2, R3.2, R4.1, Teensy4.1.G (GND), Teensy4.1.G1 (GND), Teensy4.1.G2 (GND), U1.2 (GND), U1.5 (PS1), U1.6 (PS0), U1.18 (COM2), U1.25 (GNDIO)
unnamed: BZ1.1 (+), Teensy4.1.33 (PWM)
unnamed: D1.2 (A), Teensy4.1.31 (GPIO)
unnamed: D1.1 (K), R1.1
unnamed: D2.2 (A), Teensy4.1.32 (GPIO)
unnamed: D2.1 (K), R2.1
unnamed: D3.1 (K), R3.1
unnamed: J1.1, Teensy4.1.5V (VIN)
unnamed: J1.2, J2.1, R5.2
unnamed: R4.2, R5.1, Teensy4.1.14 (A0)
unnamed: C3.2, U1.9 (CAP)
RX: J3.3, Teensy4.1.0 (RX1)
SCL: A1.2 (SCL/SPC), J4.3, Rpull1.1, Teensy4.1.19 (SCL), U1.19 (COM1)
SDA: A1.4 (SDA/SDI/SDO), J4.2, Rpull2.1, Teensy4.1.18 (SDA), U1.20 (COM0)
TX: J3.2, Teensy4.1.1 (TX1)

## KiCad design Spaceport/PCBs/Radios/medium-power-module-telemetry/medium-power-module-telemetry.kicad_pcb

Parts:
3V3, 8V0: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C0: 390p; C_0603_1608Metric
C1, C12, C17, C20, C21: 0.1u; C_0603_1608Metric
C2, C3, C7: 10u; C_0603_1608Metric
C4, C6, C14: 1u; C_0603_1608Metric
C5, C13: 4.7u; C_0603_1608Metric
C8, C11, C16, C18: 100p; C_0603_1608Metric
C9, C10, C19: 8.2p; C_0603_1608Metric
C15: 24p; C_0603_1608Metric
CB3: 10n; C_0603_1608Metric
CD1: 10u; C_0603_1608Metric
CR1: 9.1p; C_0603_1608Metric
CR2: 4.3p; C_0603_1608Metric
D1: D_Schottky; SK34SMA-3G
GPIO1, GPIO2, GPIO3: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
J2: SMA; SMA_EDGELAUNCH
J7: UART; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
L2: 4.7u; L_Abracon_ASPI-4030S
L3, L4, L10, L11: 100n; L_0603_1608Metric
L5, L6, L7, L8, L12, L13: 110n; L_0603_1608Metric
L9: 22n; L_0603_1608Metric
LChoke1: 360n; L_0603_1608Metric
LR1: 160n; L_0603_1608Metric
LR2: 120n; L_0603_1608Metric
R1, R12, R13, R14, R15, R16: 5.1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R2: 10k; R_0603_1608Metric
R3: 16.5k; R_0603_1608Metric
R4, R6, R8: 10.7k; R_0603_1608Metric
R5: 111k; R_0603_1608Metric
R7, R11: 2.49k; R_0603_1608Metric
R9: 61.9k; R_0603_1608Metric
R10: 50; R_0603_1608Metric
STAT1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
TCXO1: TG2520SMN
U1: Si4463
U2: STM32L431KBU6TR
U3, U6: LDL212PVR
U4: TLV61048DBVR
U5, U7: GRF5010
U8: BGS12P2L6

Connections:
3V3_IN: 3V3.2 (A), C1.1, C4.2, C6.1, C20.1, C21.1, J1.1, J7.1, L2.2, U2.1 (VDD), U2.5 (VDDA), U2.17 (VDD), U3.4 (VIN), U3.6 (EN), U4.4 (EN), U4.5 (VIN)
3V3_LDO: C2.1, C3.1, C5.2, CD1.1, LChoke1.1, R2.1, R3.2, TCXO1.4 (VCC), U1.6 (VDD), U1.8 (VDD), U3.3 (VOUT), U8.4 (VDD); also elsewhere on the board
8V_LDO: 8V0.2 (A), C12.1, C13.2, C17.1, L4.1, L11.1, R7.1, R9.2, R11.1, U6.3 (VOUT)
8V_TO_LDO: C7.1, C14.2, D1.1 (K), R5.1, U6.4 (VIN), U6.6 (EN)
CS: U1.15 (~SEL), U2.14 (PB0)
GND: C1.2, C2.2, C3.2, C4.1, C5.1, C6.2, C7.2, C9.2, C10.2, C12.2, C13.1, C14.1, C17.2, C19.2, C20.2, C21.2, CR1.1, J1.3, J2.2 (Ext), J7.4, L3.2, L10.2, R1.2, R4.1, R6.2, R8.1, R10.2, R12.2, R13.2, R14.2, R15.2, R16.2, U1.21 (GND), U2.16 (VSS), U2.31 (PH3/BOOT0), U2.32 (VSS), U3.1 (GND), U3.7 (EPAD), U4.2 (GND), U4.6 (FREQ), U5.17 (GND), U6.1 (GND), U6.7 (EPAD), U7.17 (GND), U8.2 (GND)
GNDX: CD1.2, TCXO1.1 (NC), TCXO1.2 (GND), U1.18 (GND)
GPIO0: U1.9 (GPIO0), U2.15 (PB1), U8.6 (CTRL)
GPIO1: GPIO1.2 (A), U1.10 (GPIO1), U2.6 (PA0/CK_IN)
GPIO2: GPIO2.2 (A), U1.19 (GPIO2), U2.7 (PA1)
GPIO3: GPIO3.2 (A), U1.20 (GPIO3), U2.8 (PA2)
IRQ: U1.11 (~IRQ), U2.10 (PA4)
LNA_IN: C16.1, L10.1, U8.3 (RF_1)
LNA_OUT: C18.2, L6.2
MISO: U1.13 (SDO), U2.12 (PA6)
MOSI: U1.14 (SDI), U2.13 (PA7)
NRST: J1.5, U2.4 (NRST)
unnamed: 3V3.1 (K), R16.1
unnamed: 8V0.1 (K), R14.1
unnamed: C0.2, C15.1, L7.1, L9.1
unnamed: C8.2, U5.3 (RF_IN), U5.4 (RF_IN)
unnamed: C9.1, L5.2, L6.1
unnamed: C10.1, L7.2, L8.1
unnamed: C11.1, L4.2, U5.9 (RF_OUT), U5.10 (RF_OUT)
unnamed: C15.2, L9.2, R10.1
unnamed: C16.2, U7.3 (RF_IN), U7.4 (RF_IN)
unnamed: C18.1, L11.2, U7.9 (RF_OUT), U7.10 (RF_OUT)
unnamed: C19.1, L12.2, L13.1
unnamed: CR2.2, L5.1, LR2.2
unnamed: D1.2 (A), L2.1, U4.1 (SW)
unnamed: GPIO1.1 (K), R13.1
unnamed: GPIO2.1 (K), R12.1
unnamed: GPIO3.1 (K), R1.1
unnamed: J2.1 (In), L13.2
unnamed 34: R15.1, STAT1.1 (K); also elsewhere on the board
unnamed: CB3.2, TCXO1.3 (OUTPUT)
unnamed: R3.1, R4.2, U3.2 (ADJ/SENSE)
unnamed: R5.2, R6.1, U4.3 (FB)
unnamed: R7.2, U5.1 (V_EN)
unnamed: R8.2, R9.1, U6.2 (ADJ/SENSE)
unnamed: R11.2, U7.1 (V_EN)
PA_IN: C8.1, L3.1, L8.2
PA_OUT: C11.2, U8.1 (RF_2)
RXn: CR2.1, LR1.2, U1.3 (RXn)
RXp: CR1.2, LR1.1, LR2.1, U1.2 (RXp)
SCK: U1.12 (SCLK), U2.11 (PA5)
SDN: R2.2, U1.1 (SDN), U2.9 (PA3)
SRX: J7.3, U2.19 (PA9)
STAT: STAT1.2 (A), U2.21 (PA11); also elsewhere on the board
STX: J7.2, U2.18 (PA8)
SWCLK: J1.2, U2.24 (PA14)
SWDIO: J1.4, U2.23 (PA13)
SW_OUT: L12.1, U8.5 (RF_IN)
TX: C0.1, LChoke1.2, U1.4 (TX); also elsewhere on the board
XO_IN: CB3.1, U1.17 (XIN)

Notes on the sheet:
RF Switch
3.3V
LDO 8V
9.1V 500mA
8V 500mA
2A current min
STM
Low Pass Filter + Antenna
Low Pass Filter
TCXO GND connected only to RF IC GNDX (pin 18)
>9V 1-2A current
LNA
Radio
LDO 3.3V
Boost
TCXO
Harmonic Termination
LEDs
3.0V 500mA
PA stage
Rx Balun Network
Set GPIO0 to high in TX mode

Board: 4 copper layers, 27.4 x 45.2 mm, 80 parts (39 on the bottom side), 55 nets.

Other parts of the board:
LC1: 360n; L_0603_1608Metric
STAT: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder

Their connections:
3V3_LDO: LC1.1; also elsewhere on the board
unnamed 34: STAT.1 (K); also elsewhere on the board
STAT: STAT.2 (A); also elsewhere on the board
TX: LC1.2; also elsewhere on the board

## KiCad design Spaceport/PCBs/dipole-breakout/dipole-breakout.kicad_pcb

Parts:
C1: C; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J1: Conn_Coaxial; SMA_EDGELAUNCH
J2, J3: Conn_01x01_Pin; Wire Pad
L1: L; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder

Connections:
GND: C1.1, J1.2 (Ext), J2.1, L1.1
unnamed: C1.2, J1.1 (In), J3.1, L1.2

Board: 2 copper layers, 15.8 x 9.0 mm, 7 parts (0 on the bottom side), 2 nets.

Other parts of the board:
H1, H2: MountingHole; MountingHole_2.2mm_M2

## Code that names these connections

File Side_Projects/Radio_Code/src/main.cpp (part):

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//     UART carries COBS-framed ARC frames in integration mode.
// ---------------------------------------------------------------------------

#define STATUS_LED PB12
#define RADIO_NRST PA6
#define RADIO_BUSY PA7
#define RADIO_NCS PA15
#define RADIO_IO8 PA3
// irq pin
#define RADIO_IO9 PA2

#define RADIO_MOSI PD7
#define RADIO_MISO PB4
#define RADIO_SCK PB3

#include "Type_2GT.h"

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  Serial.setTimeout(5000);
  Serial.begin(kHostBaud);
  delay(50);
  RAD_LOG_PRINTLN("RAD/DBG host UART up on USART1 PB6/PB7 @115200");

  pinMode(STATUS_LED, OUTPUT);

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
File Spaceport/Code/ARCH-Mega/src/pin_defs.h:

#ifndef PIN_DEFS_H
#define PIN_DEFS_H

// User vars

#define PWR_CH1_DEFAULT HIGH
#define PWR_CH2_DEFAULT HIGH
#define PWR_CH3_DEFAULT HIGH
#define PWR_CH4_DEFAULT HIGH
#define PWR_CH5_DEFAULT HIGH
#define PWR_CH6_DEFAULT HIGH

// system definitions

#define PWR_CH1 pinNametoDigitalPin(PA_0) // PA0
#define PWR_CH2 pinNametoDigitalPin(PA_1) // PA1
#define PWR_CH3 pinNametoDigitalPin(PA_2) // PA2
#define PWR_CH4 pinNametoDigitalPin(PA_3) // PA3
#define PWR_CH5 pinNametoDigitalPin(PA_4) // PA4
#define PWR_CH6 pinNametoDigitalPin(PA_5) // PA5

#define VOLT0 7 // PA7
#define VOLT1 6 // PA6
#define VOLT2 8 // PA8

// TODO: tune to be exact
#define VOLT0_MAX 8.643  // Bat voltage
#define VOLT1_MAX 5.149  // 5V rail
#define VOLT2_MAX 14.528 // Charge voltage

#define BAT_VOLT VOLT0
#define RAIL_VOLT VOLT1
#define CHARGE_VOLT VOLT2

#define BAT_VOLT_MAX VOLT0_MAX
#define RAIL_VOLT_MAX VOLT1_MAX
#define CHARGE_VOLT_MAX VOLT2_MAX

#define STAT pinNametoDigitalPin(PC_15) // PC15

#endif

File Side_Projects/STM32FC/src/main.cpp (part):

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// flip the writes if your board sinks current to light them.
#define HEARTBEAT_LED PE5
#define TELEM_LED PE6
#define RADIO_NRST PC13
#define RADIO_BUSY PE3
#define RADIO_NCS PA15
#define RADIO_IO8 PA3
// irq pin
#define RADIO_IO9 PE2

#define RADIO_MOSI PD7
#define RADIO_MISO PB4
#define RADIO_SCK PB3
#define TELEMETRY_UART_TX PB13
#define TELEMETRY_UART_RX PB12
#define BATTERY_SENSE_PIN PC2_C

#include "LocalFileCommands.h"
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
File Spaceport/Code/Radio-Transceiver/test/telem_radio.cpp:

#include <Arduino.h>
#include "Si4464.h"
#include "List.h"

#define MSG_SIZE_OVRD 200
#include "RadioMessage.h"

#define IS_ACTIVE_NODE true
#define RX_TIMEOUT 100     // ms
#define CHANNEL 40         // Freq = 220 + (CHANNEL * 0.1) MHz
#define SERIAL_BAUD 115200 // bits/s
#define END_CHAR '0'

const uint8_t STAT_PIN = (uint8_t)pinNametoDigitalPin(PA_11);

// Base Freq: 220MHz
// Channel Step: 100kHz
// Channel Number: 10
// Carrier Freq: 221MHz

Si4464HardwareConfig hwcfg = {
    MOD_4GFSK, // modulation
    DR_100k,   // data rate
    CHANNEL,   // channel
    1,         // tx power
    192,       // preamble length
    32         // required received valid preamble
};

Si4464PinConfig pincfg = {
    &SPI,                               // spi bus to use
    (uint8_t)pinNametoDigitalPin(PB_0), // cs
    (uint8_t)pinNametoDigitalPin(PA_3), // sdn
    (uint8_t)pinNametoDigitalPin(PA_4), // irq
    (uint8_t)pinNametoDigitalPin(PB_1), // gpio0
    (uint8_t)pinNametoDigitalPin(PA_0), // gpio1
    (uint8_t)pinNametoDigitalPin(PA_1), // gpio2
    (uint8_t)pinNametoDigitalPin(PA_2), // gpio3
};

Si4464 radHW(hwcfg, pincfg);

Radio radio(&radHW, IS_ACTIVE_NODE, RX_TIMEOUT);

HardwareSerial Serial1(PA_10, PA_9);

Message m;
bool serialReadLock = false;

uint32_t ledTimer = millis();
uint8_t g_times = 0;
uint32_t g_interval = 0;
bool ledOn = false;
void blink(uint8_t times, uint32_t interval);
void updateBlink();

uint8_t testBuf[8] = {1, 2, 3, 4, 5, 6, 7, 8};

void setup()
{
    // set correct SPI pins
    SPI.setMISO(PA_6);
    SPI.setMOSI(PA_7);
    SPI.setSCLK(PA_5);

    Serial1.begin(SERIAL_BAUD);
    pinMode(STAT_PIN, OUTPUT);

    delay(1000);
    Serial1.println("Starting radio");

    if (!radHW.begin())
    {
        Serial1.println("ERROR: radio failed to begin");
        while (true)
        {
            digitalWrite(STAT_PIN, HIGH);
            delay(1000);
            digitalWrite(STAT_PIN, LOW);
            delay(1000);
        }
    }

    digitalWrite(STAT_PIN, HIGH);
    delay(500);
    digitalWrite(STAT_PIN, LOW);
    delay(500);
    Serial1.println("Radio Started");

    // flush serial
    while (Serial1.available())
        Serial1.read();

    // TODO: setup debug serial
}

uint32_t timer = millis();

void loop()
{
    // if (millis() - timer > 1000)
    // {
    //     timer = millis();
    //     radHW.tx(testBuf, sizeof(testBuf));
    //     // Serial.println("TX");
    // }

    // Serial.println("main.cpp before tx");
    // Serial.flush();

    // check for input to be transmitted
    while (Serial1.available() && m.size < Message::maxSize)
    {
        // will only occur when first getting serial data
        if (!serialReadLock)
            serialReadLock = true;
        // read in character
        char c = Serial1.read();

        // denote complete messages by \n for now (text only)
        if (c == END_CHAR)
        {
            Serial1.println("main.cpp Sending msg ");
            Serial1.write(m.buf, m.size);
            Serial1.flush();
            delay(1000);
            // send complete message
            radio.send(&m);
            Serial1.println("\nafter send");
            Serial1.flush();
            delay(1000);

            m.clear();
            serialReadLock = false;
            // blink(1, 100);
            break;
        }
        else
            m.append(c);
    }

    // Serial.println("main.cpp before rx");
    // Serial.flush();

    // check for received messages
    // if (!serialReadLock && radio.receive(&m))
    // {
    //     // Serial.println("main.cpp");
    //     // Serial.flush();
    //     // m.write(Serial1);
    //     for (int i = 0; i < m.size; i++)
    //     {
    //         Serial1.print(m.buf[i]);
    //         Serial1.print(" ");
    //     }
    //     Serial1.println();
    //     m.clear();
    //     Serial1.print("RSSI: ");
    //     Serial1.println(radHW.RSSI());
    //     // m.fill((uint8_t *)"ACK ", sizeof("ACK "));
    //     // radio.send(&m);
    //     // m.clear();
    //     // blink(2, 100);
    // }
    // Serial.println("main.cpp after rx");
    // Serial.flush();

    // if somehow we reach the max message size, dump the data to prevent lockup
    // if (m.size == Message::maxSize)
    //     m.clear();

    // Serial.println("main.cpp before update");
    // Serial.flush();

    // radio update
    radio.update();
    // updateBlink();

    // Serial.println("main.cpp after update");
    // Serial.flush();
}

void blink(uint8_t times, uint32_t interval)
{
    g_times = times;
    g_interval = interval;
    ledTimer = millis();
    ledOn = true;
    digitalWrite(STAT_PIN, HIGH);
}

// this will not work particularly well without queueing
// but it makes light go flashy if data sent so it work
void updateBlink()
{
    if (millis() - ledTimer > g_interval && g_times > 0)
    {
        ledTimer = millis();
        ledOn = !ledOn;
        digitalWrite(STAT_PIN, ledOn ? HIGH : LOW);
        // only decrement times after 1 cycle
        if (ledOn)
            g_times--;
    }
    if (g_times == 0)
    {
        digitalWrite(STAT_PIN, LOW);
    }
}

File Side_Projects/STM32FCTest/custom_variants/stm32h723vehx/PeripheralPins.c (part):

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  {PA_3_ALT2,  TIM15, STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF4_TIM15, 2, 0)}, // TIM15_CH2
  {PA_5,       TIM2,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF1_TIM2, 1, 0)}, // TIM2_CH1
  {PA_5_ALT1,  TIM8,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF3_TIM8, 1, 1)}, // TIM8_CH1N
  {PA_6,       TIM3,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF2_TIM3, 1, 0)}, // TIM3_CH1
  {PA_6_ALT1,  TIM13, STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF9_TIM13, 1, 0)}, // TIM13_CH1
  {PA_7,       TIM1,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF1_TIM1, 1, 1)}, // TIM1_CH1N
  {PA_7_ALT1,  TIM3,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF2_TIM3, 2, 0)}, // TIM3_CH2
  {PA_7_ALT2,  TIM8,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF3_TIM8, 1, 1)}, // TIM8_CH1N
  {PA_7_ALT3,  TIM14, STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF9_TIM14, 1, 0)}, // TIM14_CH1
  {PA_8,       TIM1,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF1_TIM1, 1, 0)}, // TIM1_CH1
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  {PB_1_ALT1,  TIM3,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF2_TIM3, 4, 0)}, // TIM3_CH4
  {PB_1_ALT2,  TIM8,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF3_TIM8, 3, 1)}, // TIM8_CH3N
  {PB_3,       TIM2,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF1_TIM2, 2, 0)}, // TIM2_CH2
  {PB_4,       TIM3,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF2_TIM3, 1, 0)}, // TIM3_CH1
  {PB_5,       TIM3,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF2_TIM3, 2, 0)}, // TIM3_CH2
  {PB_6,       TIM4,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF2_TIM4, 1, 0)}, // TIM4_CH1
  {PB_6_ALT1,  TIM16, STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF1_TIM16, 1, 1)}, // TIM16_CH1N
  {PB_7,       TIM4,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF2_TIM4, 2, 0)}, // TIM4_CH2
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  {PB_13,      TIM1,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF1_TIM1, 1, 1)}, // TIM1_CH1N
  {PB_14,      TIM1,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF1_TIM1, 2, 1)}, // TIM1_CH2N
  {PB_14_ALT1, TIM8,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF3_TIM8, 2, 1)}, // TIM8_CH2N
  {PB_14_ALT2, TIM12, STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF2_TIM12, 1, 0)}, // TIM12_CH1
  {PB_15,      TIM1,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF1_TIM1, 3, 1)}, // TIM1_CH3N
  {PB_15_ALT1, TIM8,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF3_TIM8, 3, 1)}, // TIM8_CH3N
  {PB_15_ALT2, TIM12, STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF2_TIM12, 2, 0)}, // TIM12_CH2
  {PC_6,       TIM3,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF2_TIM3, 1, 0)}, // TIM3_CH1
  {PC_6_ALT1,  TIM8,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF3_TIM8, 1, 0)}, // TIM8_CH1
  {PC_7,       TIM3,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF2_TIM3, 2, 0)}, // TIM3_CH2
  {PC_7_ALT1,  TIM8,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF3_TIM8, 2, 0)}, // TIM8_CH2
  {PC_8,       TIM3,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF2_TIM3, 3, 0)}, // TIM3_CH3
  {PC_8_ALT1,  TIM8,  STM_PIN_DATA_EXT(STM_MODE_AF_PP, GPIO_PULLUP, GPIO_AF3_TIM8, 3, 0)}, // TIM8_CH3
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