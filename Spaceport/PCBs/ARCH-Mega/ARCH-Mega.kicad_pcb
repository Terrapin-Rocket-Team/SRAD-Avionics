# Repository Terrapin-Rocket-Team/SRAD-Avionics

File README.md:

# SRAD-Avionics

Code, KiCad projects, and supporting experiments for the Terrapin Rocket Team
avionics subteam. The canonical branch is `main`.

This is a historical engineering repository as well as a source repository.
Some PlatformIO projects are maintained integration targets; others are
preserved prototypes and are known not to build. Do not assume that every
directory represents current flight hardware.

## Repository layout

- `Spaceport/` contains competition-rocket firmware, PCBs, and mechanical work.
- `Side_Projects/` contains flight-computer integrations, radio work, training,
  and experiments.
- `Apollo/` contains the Apollo project material organized by term.
- `docs/2026-consolidation-status.md` records the dated branch consolidation,
  verified builds, and known legacy failures.
- `docs/software-stack.md` is the user-facing setup and integration path for
  the current Astra-based flight software.
- `docs/stm32fc-integration.md` records the source-level STM32FC pin, sensor,
  storage, and communications configuration.
- `docs/validation-checklist.md` is the staged bench-to-flight verification
  template; copy it into a mission-specific test record.

KiCad boards normally consist of `.kicad_pro`, `.kicad_sch`, and `.kicad_pcb`
files. Open the `.kicad_pro` file to work on a board.

## Clone and prerequisites

Install Git and PlatformIO Core, or VS Code with the PlatformIO extension. Clone
the repository and its Ground Station submodule with:

```bash
git clone --recurse-submodules https://github.com/Terrapin-Rocket-Team/SRAD-Avionics.git
cd SRAD-Avionics
```

For an existing clone:

```bash
git submodule update --init --recursive
```

Open the specific directory containing the desired `platformio.ini` in VS Code,
or run PlatformIO from that directory. Do not run a repository-wide build as a
first setup check: the repository intentionally retains known-broken legacy
projects.

## Current integration smoke test

Read the [software stack and integration guide](docs/software-stack.md) before
starting new flight-computer work. Then review the
[STM32FC integration reference](docs/stm32fc-integration.md) and use the
[bench and flight readiness checklist](docs/validation-checklist.md).

`Side_Projects/STM32FC` is the maintained smoke test for the current
Astra-Rocket -> Astra dependency chain:

```bash
cd Side_Projects/STM32FC
pio run
```

This compiles firmware only. Uploading, hardware-in-the-loop testing, deployment
outputs, radios, and sensors require the matching hardware and must be verified
separately before flight.

## Build status and legacy projects

See [the 2026 consolidation status](docs/2026-consolidation-status.md) for the
last clean build matrix. At that handoff point, ten projects passed and nine
legacy or mixed projects had documented failures. The existing GitHub Actions
workflow still attempts every `platformio.ini`, but its shell command does not
reliably propagate individual project failures. A green PlatformIO workflow is
therefore not a substitute for the documented matrix or the STM32 smoke test.

The repository-wide KiCad DRC workflow is known to fail across both the
pre-consolidation and consolidated histories. Review each board's DRC output
before fabrication.

Owner-controlled jhauerst branches were deliberately excluded from the 2026
consolidation and should be coordinated with their owner rather than merged or
deleted as repository cleanup.

## KiCad design Spaceport/PCBs/ARCH-Mega/ARCH-Mega.kicad_pcb

Parts:
5V_1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C1, C3, C6, C8: 100nF; C_0603_1608Metric
C2, C10: 22uF; C_0805_2012Metric
C4: 100uF; Wurth_SMD_Cap
C5: 2.2uF; C_0603_1608Metric
C7: 470pF; C_0603_1608Metric
C9: 4.7uF; C_0603_1608Metric
C11: 220uF; Wurth_SMD_Cap
C15: 1uF; C_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x04; JST_XH_1x4_P2.50mm_Horizontal_Small
J2: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
L1: 1.5uH; HCM1A1305
R1: 100k; R_0603_1608Metric
R2: 15k; R_0603_1608Metric
R3: 10k; R_0603_1608Metric
R4, R9: 2k; R_0603_1608Metric
R5, R25, R41, R43: 10.7k; R_0603_1608Metric
R6, R31: 19.1k; R_0603_1608Metric
R7: 110k; R_0603_1608Metric
R8: 14.7k; R_0603_1608Metric
R10, R11: 4.7k; R_0603_1608Metric
R39: 1k; R_0603_1608Metric
R40: 17.4k; R_0603_1608Metric
R42: 36.5k; R_0603_1608Metric
STAT1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: STM32C011F6U6TR; PARTREV 3
U2: TPS51388VABR; TPS513885VABR
U3: LDL212PVR

Connections:
3V3_MCU: C3.1, C9.2, J1.4, J2.1, R6.2, R10.1, R11.1, U1.2 (VDD/VDDA), U3.3 (VOUT); also elsewhere on the board
BUCK_EN: R2.2, R3.2, U2.5 (MODE), U2.6 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C8.2, C9.1, C10.2, C11.2, C15.1, J1.1, J2.3, R3.1, R4.2, R5.1, R8.2, R9.2, R31.1, R41.1, R43.1, U1.3 (VSS/VSSA), U2.3 (PGND), U2.9 (FBG), U2.11 (PGND), U3.1 (GND), U3.7 (EPAD); also elsewhere on the board
NRST: J2.5, U1.4 (PF2-~RST)
unnamed: 5V_1.1 (K), R9.1
unnamed: C6.1, L1.1, U2.2 (SW), U2.12 (SW)
unnamed: C7.2, R39.1
unnamed: R4.1, STAT1.1 (K)
unnamed: R25.1, R31.2, U1.11 (PA6)
unnamed: R40.1, R41.2, U1.12 (PA7)
unnamed: R42.1, R43.2, U1.13 (PA8)
unnamed: R7.2, R8.1, R39.2, U2.7 (FB)
unnamed: R1.1, U2.4 (PG)
unnamed: C6.2, U2.13 (VBST)
unnamed: C5.2, R1.2, U2.10 (VCC)
unnamed: R5.2, R6.1, U3.2 (ADJ/SENSE)
PWR1: U1.5 (PA0); also elsewhere on the board
PWR2: U1.6 (PA1); also elsewhere on the board
PWR3: U1.7 (PA2); also elsewhere on the board
PWR4: U1.8 (PA3); also elsewhere on the board
PWR5: U1.9 (PA4); also elsewhere on the board
PWR6: U1.10 (PA5); also elsewhere on the board
SCL: R10.2, U1.18 (PB6); also elsewhere on the board
SDA: R11.2, U1.19 (PB7); also elsewhere on the board
SRX: J1.2, U1.15 (PA12(PA10))
STAT1: STAT1.2 (A), U1.1 (PC15-OSCX_OUT)
STX: J1.3, U1.14 (PA11(PA9))
SWCLK: J2.2, U1.17 (PA14-BOOT0)
SWDIO: J2.4, U1.16 (PA13)
VOLT1: 5V_1.2 (A), C7.1, C8.1, C10.1, C11.1, C15.2, L1.2, R7.1, R25.2, U2.8 (BYP), U3.4 (VIN), U3.6 (EN); also elsewhere on the board

Notes on the sheet:
I2C Bus Pull Up Resistors
5V Buck converter
VIN 5-24V
STM
3.3V 500mA
LEDs
LDO 3.3V
VOUT 5.1V 10A

Parts:
C41, C44, C47, C50, C51, C52: 2.2uF; C_0603_1608Metric
C42, C46, C49, C56, C57, C58: 100nF; C_0603_1608Metric
C43, C45, C48, C53, C54, C55: 3.3nF; C_0603_1608Metric
OPWR1, OPWR2, OPWR3, OPWR4, OPWR5, OPWR6: JST; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
PWR1, PWR2, PWR3, PWR4, PWR5, PWR6: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R47, R60, R62, R66, R67, R68: 2k; R_0603_1608Metric
R48, R59, R61, R63, R64, R65: 680; R_0603_1608Metric
U4, U5, U6, U7, U8, U9: TPS259531DSGR; SON50P200X200X80-9N

Connections:
BPS_1: C42.2, U4.5 (OUT); also elsewhere on the board
BPS_2: C46.2, U5.5 (OUT); also elsewhere on the board
BPS_3: C49.2, U6.5 (OUT); also elsewhere on the board
BPS_4: C56.2, U7.5 (OUT); also elsewhere on the board
BPS_5: C57.2, U8.5 (OUT); also elsewhere on the board
BPS_6: C58.2, U9.5 (OUT); also elsewhere on the board
GND: C41.2, C42.1, C43.1, C44.2, C45.1, C46.1, C47.2, C48.1, C49.1, C50.2, C51.2, C52.2, C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, OPWR1.2, OPWR2.2, OPWR3.2, OPWR4.2, OPWR5.2, OPWR6.2, R47.2, R48.1, R59.1, R60.2, R61.1, R62.2, R63.1, R64.1, R65.1, R66.2, R67.2, R68.2, U4.8 (GND), U4.9 (PAD), U5.8 (GND), U5.9 (PAD), U6.8 (GND), U6.9 (PAD), U7.8 (GND), U7.9 (PAD), U8.8 (GND), U8.9 (PAD), U9.8 (GND), U9.9 (PAD); also elsewhere on the board
LOAD_1: OPWR1.1, PWR1.2 (A); also elsewhere on the board
LOAD_2: OPWR2.1, PWR2.2 (A); also elsewhere on the board
LOAD_3: OPWR3.1, PWR3.2 (A); also elsewhere on the board
LOAD_4: OPWR4.1, PWR4.2 (A); also elsewhere on the board
LOAD_5: OPWR5.1, PWR5.2 (A); also elsewhere on the board
LOAD_6: OPWR6.1, PWR6.2 (A); also elsewhere on the board
unnamed: PWR1.1 (K), R47.1
unnamed: PWR2.1 (K), R60.1
unnamed: PWR3.1 (K), R62.1
unnamed: PWR4.1 (K), R66.1
unnamed: PWR5.1 (K), R67.1
unnamed: PWR6.1 (K), R68.1
unnamed: R48.2, U4.7 (ILM)
unnamed: C43.2, U4.1 (dVdt)
unnamed: R59.2, U5.7 (ILM)
unnamed: C45.2, U5.1 (dVdt)
unnamed: R61.2, U6.7 (ILM)
unnamed: C48.2, U6.1 (dVdt)
unnamed: R63.2, U7.7 (ILM)
unnamed: C53.2, U7.1 (dVdt)
unnamed: R64.2, U8.7 (ILM)
unnamed: C54.2, U8.1 (dVdt)
unnamed: R65.2, U9.7 (ILM)
unnamed: C55.2, U9.1 (dVdt)
PWR1: U4.2 (EN/UVLO); also elsewhere on the board
PWR2: U5.2 (EN/UVLO); also elsewhere on the board
PWR3: U6.2 (EN/UVLO); also elsewhere on the board
PWR4: U7.2 (EN/UVLO); also elsewhere on the board
PWR5: U8.2 (EN/UVLO); also elsewhere on the board
PWR6: U9.2 (EN/UVLO); also elsewhere on the board
VOLT1: C41.1, C44.1, C47.1, C50.1, C51.1, C52.1, U4.3 (IN), U4.4 (IN), U5.3 (IN), U5.4 (IN), U6.3 (IN), U6.4 (IN), U7.3 (IN), U7.4 (IN), U8.3 (IN), U8.4 (IN), U9.3 (IN), U9.4 (IN); also elsewhere on the board

Notes on the sheet:
Power Control
680 ohms sets a 3A limit per the datasheet

Parts:
BSTAT1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C25: 470pF; C_0603_1608Metric
C26, C36, C37, C38: 100nF; C_0603_1608Metric
C27: 47nF; C_0603_1608Metric
C28, C32: 2.2uF; C_0603_1608Metric
C29, C30: 10uF; C_0603_1608Metric
C31, C33, C34, C35: 1uF; C_0603_1608Metric
D1, D2: D_Schottky; Schottky_3A_DO-214AC_SMA
ECHG1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J3: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J4: SW; JST_XH_1x2_P2.50mm_Horizontal_Small
J5: BAT; HPWR_CONN_CP-01404140
J6: Conn_01x04; JST_XH_1x4_P2.50mm_Horizontal_Small
J7: Conn_01x03; JST_XH_1x3_P2.50mm_Horizontal_Small
J8: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
L2: 2.2uH; AMPI0640ED2R2MT
Q1: PMOS; STL6P3LLH6
Q2, Q5: PMOS; SI7615ADN-T1-GE3
Q4, Q6: NMOS; 2N7002
R16: 90.9k; R_0603_1608Metric
R17, R19: 13.7k; R_0603_1608Metric
R18, R20, R24, R30, R33, R34, R44, R45: 10k; R_0603_1608Metric
R21, R27, R28: 1k; R_0603_1608Metric
R22: 22k; R_0603_1608Metric
R23: 100k; R_0603_1608Metric
R26, R35, R36: 100; R_0603_1608Metric
R29: 0; R_0603_1608Metric
R37: 261; R_0603_1608Metric
R38: 160; R_0603_1608Metric
R46: 2k; R_0603_1608Metric
U10: BQ25306RTER; PARTREV A
U11: STUSB4500QTR
U12: BQ29200DRBR; BQ2900DRBR

Connections:
2V7: C31.2, U11.23 (VREG_2V7)
DISCH: R28.2, U11.9 (DISCH)
GND: C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), J4.2, J5.3, J5.4, J6.3, J6.4, J7.3, Q4.3 (S), Q6.3 (S), R19.2, R20.1, R24.2, R30.1, R33.2, U10.11 (GND), U10.12 (GND__1), U10.17 (EXP), U11.3 (NC), U11.10 (GND), U11.12 (ADDR0), U11.13 (ADDR1), U11.22 (VSYS), U11.25 (EP), U12.5 (GND), U12.9 (EPAD); also elsewhere on the board
unnamed: BSTAT1.1 (K), R27.1
unnamed: C26.2, R26.1
unnamed: ECHG1.2 (A), R46.1
unnamed: ECHG1.1 (K), Q6.1 (D)
unnamed: J3.A5 (CC1), U11.1 (CC1DB), U11.2 (CC1)
unnamed: J3.B5 (CC2), U11.4 (CC2), U11.5 (CC2DB)
unnamed: C26.1, Q1.1 (D), R28.1, R29.1
unnamed: Q1.2 (G), R22.2, R23.1, R26.2
unnamed: Q4.1 (D), R34.2, U12.6 (~CB_EN)
unnamed: Q5.2 (G), R44.1, R45.2
unnamed: C27.1, U10.15 (BTST)
unnamed: C25.1, R16.1, R17.2, U10.9 (FB)
unnamed: R17.1, U10.8 (FB_GND)
unnamed: R19.1, U10.4 (ICHG)
unnamed: C30.2, U10.16 (PMID)
unnamed: R27.2, U10.3 (STAT)
unnamed: C27.2, L2.1, U10.13 (SW), U10.14 (SW__1)
unnamed: R18.1, R20.2, U10.7 (TS)
unnamed: R24.1, U11.6 (RESET)
unnamed: C33.2, U11.21 (VREG_1V2)
unnamed: C35.2, U12.4 (CD)
unnamed: C38.2, R38.1, U12.2 (VC1)
unnamed: R35.1, U12.3 (VC1_CB)
unnamed: C37.2, R37.1, U12.1 (VC2)
unnamed: C36.2, R34.1, R36.1, U12.7 (VDD)
REGN: BSTAT1.2 (A), C28.2, R18.2, U10.2 (REGN)
SCL: J8.2, U11.7 (SCL); also elsewhere on the board
SDA: J8.1, U11.8 (SDA); also elsewhere on the board
SW: J4.1, R45.1; also elsewhere on the board
VBUS: D2.2 (A), Q6.2 (G), R29.2
VBUS_DISCH: R21.2, U11.18 (VBUS_VS_DISCH)
VBUS_EN: R22.1, U11.16 (VBUS_EN_SNK)
VC1: J7.1, R38.2
VC2: J7.2, R35.2, R37.2
VUSB: C34.2, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), Q1.3 (S), R21.1, R23.2, R46.2, U11.24 (VDD)

Notes on the sheet:
VCHG 9-20V
Charging
Battery Balance
VBUS 9-20V
USB-C Charging

Parts:
C39, C40: 100nF; C_0603_1608Metric
D3, D4, D5, D6: LED; LED_01005_0402Metric
R49, R50, R51, R56, R57, R58: 0.04; R_1206_3216Metric
R52, R53, R54, R55: 2k; R_0603_1608Metric
U13, U14: INA3221; QFN65P400X400X100-17N

Connections:
3V3_MCU: C39.1, C40.1, R52.1, R53.1, R54.1, R55.1, U13.4 (VS), U13.16 (VPU), U14.4 (VS), U14.5 (A0), U14.16 (VPU); also elsewhere on the board
BPS_1: R49.2, U13.12 (IN+1); also elsewhere on the board
BPS_2: R50.2, U13.15 (IN+2); also elsewhere on the board
BPS_3: R51.2, U13.2 (IN+3); also elsewhere on the board
BPS_4: R56.2, U14.12 (IN+1); also elsewhere on the board
BPS_5: R57.2, U14.15 (IN+2); also elsewhere on the board
BPS_6: R58.2, U14.2 (IN+3); also elsewhere on the board
GND: C39.2, C40.2, U13.3 (GND), U13.5 (A0), U13.17 (EP), U14.3 (GND), U14.17 (EP); also elsewhere on the board
LOAD_1: R49.1, U13.11 (IN-1); also elsewhere on the board
LOAD_2: R50.1, U13.14 (IN-2); also elsewhere on the board
LOAD_3: R51.1, U13.1 (IN-3); also elsewhere on the board
LOAD_4: R56.1, U14.11 (IN-1); also elsewhere on the board
LOAD_5: R57.1, U14.14 (IN-2); also elsewhere on the board
LOAD_6: R58.1, U14.1 (IN-3); also elsewhere on the board
unnamed: D3.2 (A), R52.2
unnamed: D3.1 (K), U13.9 (CRITICAL)
unnamed: D4.2 (A), R53.2
unnamed: D4.1 (K), U13.8 (WARNING)
unnamed: D5.2 (A), R54.2
unnamed: D5.1 (K), U14.8 (WARNING)
unnamed: D6.2 (A), R55.2
unnamed: D6.1 (K), U14.9 (CRITICAL)
SCL: U13.6 (SCL), U14.6 (SCL); also elsewhere on the board
SDA: U13.7 (SDA), U14.7 (SDA); also elsewhere on the board

Notes on the sheet:
Current Monitoring

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
Board: 4 copper layers, 47.0 x 62.0 mm, 165 parts (37 on the bottom side), 108 nets.

Other parts of the board:
R32: 10k; R_0603_1608Metric

Their connections:
SW: R32.1; also elsewhere on the board

File Spaceport/PCBs/ARCH-Mega/BOM/ARCH-Mega_BOM.xlsx:

Reference | Qty | Value | Footprint | Datasheet | MPN | Availability | Distributor | Link | Possible Replacement
5V_1,BSTAT1,ECHG1,PWR1,PWR2,PWR3,PWR4,PWR5,PWR6,STAT1 | 10 | LED | LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder | Yellow LED | XL-2012WYC | In Stock | DigiKey | https://www.digikey.com/en/products/detail/xinglight/XL-2012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
C1,C3,C6,C8,C26,C36,C37,C38,C39,C40,C42,C46,C49,C56,C57,C58 | 16 | 100nF | Capacitor_SMD:C_0603_1608Metric |  |  | Cypress
C2,C10 | 2 | 22uF | Capacitor_SMD:C_0805_2012Metric |  |  | Cypress
C4 | 1 | 100uF | Avionics:Wurth_SMD_Cap |  |  | Cypress
C5,C28,C32,C41,C44,C47,C50,C51,C52 | 9 | 2.2uF | Capacitor_SMD:C_0603_1608Metric |  |  | Cypress
C7,C25 | 2 | 470pF | Capacitor_SMD:C_0603_1608Metric |  |  | Cypress
C9 | 1 | 4.7uF | Capacitor_SMD:C_0603_1608Metric |  |  | Cypress
C11 | 1 | 220uF | Avionics:Wurth_SMD_Cap |  |  | Cypress
C15,C31,C33,C34,C35 | 5 | 1uF | Capacitor_SMD:C_0603_1608Metric |  |  | Cypress
C27 | 1 | 47nF | Capacitor_SMD:C_0603_1608Metric |  |  | Cypress
C29,C30 | 2 | 10uF | Capacitor_SMD:C_0603_1608Metric |  |  | Cypress
C43,C45,C48,C53,C54,C55 | 6 | 3.3nF | Capacitor_SMD:C_0603_1608Metric |  |  | Cypress
D1,D2 | 2 | D_Schottky | Avionics:Schottky_3A_DO-214AC_SMA |  | CDBA340-HF | In Stock | DigiKey | https://www.digikey.com/en/products/detail/comchip-technolog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
D3,D4,D5,D6 | 4 | LED | LED_SMD:LED_01005_0402Metric |  |  | Cypress
J1,J6 | 2 | Conn_01x04 | Avionics:JST_XH_1x4_P2.50mm_Horizontal_Small |  | S4B-XH-A | In Stock | DigiKey | https://www.digikey.com/en/products/detail/jst-sales-america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
J2 | 1 | Conn_01x05_Pin | Connector_PinHeader_2.54mm:PinHeader_1x05_P2.54mm_Vertical |  | HTSW-105-07-T-S | In Stock | DigiKey | https://www.digikey.com/en/products/detail/samtec-inc/HTSW-1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
J3 | 1 | USB_C_Receptacle_USB2.0_16P | Connector_USB:USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal | https://www.usb.org/sites/default/files/documents/usb_type-c.zip | USB4105-GF-A | In Stock | DigiKey | https://www.digikey.com/en/products/detail/gct/USB4105-GF-A/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
J4 | 1 | SW | Avionics:JST_XH_1x2_P2.50mm_Horizontal_Small |  | S2B-XH-A-1 | In Stock | DigiKey | https://www.digikey.com/en/products/detail/jst-sales-america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
J5 | 1 | BAT | Avionics:HPWR_CONN_CP-01404140 |  | CP-01404140 | In Stock | DigiKey | https://www.digikey.com/en/products/detail/cvilux-usa/CP-014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
J7 | 1 | Conn_01x03 | Avionics:JST_XH_1x3_P2.50mm_Horizontal_Small |  | S3B-XH-A-1 | In Stock | DigiKey | https://www.digikey.com/en/products/detail/jst-sales-america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
J8 | 1 | Conn_01x02 | Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical |  | TSW-102-07-T-S | In Stock | DigiKey | https://www.digikey.com/en/products/detail/samtec-inc/TSW-10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
L1 | 1 | 1.5uH | Avionics:HCM1A1305 |  |  | In Stock | DigiKey | https://www.digikey.com/en/products/detail/eaton-electronics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
L2 | 1 | 2.2uH | Avionics:AMPI0640ED2R2MT |  |  | Out of Stock | DigiKey | https://www.digikey.com/en/products/detail/arlitech-electron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 | https://www.digikey.com/en/products/detail/w%C3%BCrth-elektr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
OPWR1,OPWR2,OPWR3,OPWR4,OPWR5,OPWR6 | 6 | JST | custom_footprints:JST_S2B-PH-K-S_LF__SN_ |  | S2P-VH | In Stock | DigiKey | https://www.digikey.com/en/products/detail/jst-sales-america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
Q1 | 1 | PMOS | Avionics:STL6P3LLH6 | https://ngspice.sourceforge.io/docs/ngspice-html-manual/manu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 | STL6P3LLH6 | In Stock | DigiKey | https://www.digikey.com/en/products/detail/stmicroelectronic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
Q2,Q3,Q5 | 3 | PMOS | Avionics:SI7615ADN-T1-GE3 | https://ngspice.sourceforge.io/docs/ngspice-html-manual/manu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 | SI7615ADN-T1-GE3 | In Stock | DigiKey | https://www.digikey.com/en/products/detail/vishay-siliconix/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
Q4,Q6 | 2 | NMOS | Avionics:2N7002 | https://ngspice.sourceforge.io/docs/ngspice-html-manual/manu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 | 2N7002-7-F | In Stock | DigiKey | https://www.digikey.com/en/products/detail/diodes-incorporat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
R1,R12,R13,R14,R15,R23,R69,R70 | 8 | 100k | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R2,R8 | 2 | 15k | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R3,R18,R20,R24,R30,R32,R33,R34,R44 | 9 | 10k | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R4,R9,R46,R47,R52,R53,R54,R55,R60,R62,R66,R67,R68 | 13 | 2k | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R5,R25,R41,R43 | 4 | 10.7k | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R6,R31 | 2 | 19.1k | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R7 | 1 | 110k | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R10,R11 | 2 | 4.7k | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R16 | 1 | 90.9k | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R17,R19 | 2 | 13.7k | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R21,R27,R28,R39 | 4 | 1k | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R22 | 1 | 22k | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R26,R35,R36 | 3 | 100 | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R29 | 1 | 0 | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R37 | 1 | 260 | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R38 | 1 | 160 | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R40 | 1 | 17.4k | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R42 | 1 | 36.5k | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R45 | 1 | 20k | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R48,R59,R61,R63,R64,R65 | 6 | 1780 | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
R49,R50,R51,R56,R57,R58 | 6 | 0.1 | Resistor_SMD:R_0603_1608Metric |  |  | Cypress
U1 | 1 | STM32C011F6U6TR | Avionics:STM32C011F6U6TR |  | STM32C011F6U6TR | In Stock | Mouser | https://www.mouser.com/en/ProductDetail/STMicroelectronics/S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
U2 | 1 | TPS51388VABR | Avionics:TPS513885VABR | https://www.ti.com/lit/gpn/tps513885 | TPS513885VABR | In Stock | DigiKey | https://www.digikey.com/en/products/detail/texas-instruments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
U3 | 1 | LDL212PVR | Avionics:LDL212PVR | https://www.st.com/resource/en/datasheet/ldl212.pdf | LDL212PVR | In Stock | DigiKey | https://www.digikey.com/en/products/detail/stmicroelectronic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
U4,U5,U6,U7,U8,U9 | 6 | TPS259531DSGR | custom_footprints:SON50P200X200X80-9N |  | TPS259531DSGR | In Stock | DigiKey | https://www.digikey.com/en/products/detail/texas-instruments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
U10 | 1 | BQ25306RTER | Avionics:BQ25306RTER |  | BQ25306RTER | In Stock | DigiKey | https://www.digikey.com/en/products/detail/texas-instruments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
U11 | 1 | STUSB4500QTR | Avionics:STUSB4500QTR | https://www.st.com/resource/en/datasheet/stusb4500.pdf | STUSB4500QTR | In Stock | DigiKey | https://www.digikey.com/en/products/detail/stmicroelectronic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
U12 | 1 | BQ29200DRBR | Avionics:BQ2900DRBR |  | BQ29200DRBR | In Stock | DigiKey | https://www.digikey.com/en/products/detail/texas-instruments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
U13,U14 | 2 | INA3221 | custom_footprints:QFN65P400X400X100-17N | http://www.ti.com/lit/ds/symlink/ina3221.pdf | INA3221AIRGVR | In Stock | DigiKey | https://www.digikey.com/en/products/detail/texas-instruments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
Add-ons
VHR-2N (JST female connector) | 6 | VHR-2N |  |  | VHR-2N | In Stock | DigiKey | https://www.digikey.com/en/products/detail/jst-sales-america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
JST Crimp Connectors (SH series for the specific JST connector) | 12 | SVH-41T-P1.1 |  |  | SVH-41T-P1.1 | In Stock | DigiKey | https://www.digikey.com/en/products/detail/jst-sales-america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

Notices in the files:
Side_Projects/STM32FCTest/custom_variants/stm32h723vehx/PeripheralPins.c:
Copyright (c) 2020, STMicroelectronics
All rights reserved.
This software component is licensed by ST under BSD 3-Clause license,
the "License"; You may not use this file except in compliance with the
License. You may obtain a copy of the License at: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
