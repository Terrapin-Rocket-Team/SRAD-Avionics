# Repository Terrapin-Rocket-Team/SRAD-Avionics (continued)

## KiCad design Side_Projects/radio_interface/radio_interface.kicad_pcb

Parts:
C1, C5, C6, C7, C12: 10uF; C_0805_2012Metric
C2, C8, C11: 100nF; C_0603_1608Metric
C3, C4, C9, C10: 22uF; C_0805_2012Metric
D1, D2: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1: BATTERY_IN; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J2: POWER_SWITCH; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
L1: 10uH; IND_ASPI-6045S-100M-T
L2: 4.7uH; L_Abracon_ASPI-4030S
R1: 249k; R_0603_1608Metric
R2: 62k; R_0603_1608Metric
R3, R4, R5: 10k; R_0603_1608Metric
R6, R7: 1k; R_0603_1608Metric
U1: E28-2G4M27S
U2: AP63201WU; TSOT-23-6
U3: NCP186AMX330TAG; VREG_NCP186AMX330TAG; PARTREV 7
U4: AP63205WU; TSOT-23-6
U5: Teensy4.1; Teensy_4.1_Compact

Connections:
/3V3_RADIO: C6.1, C11.1, C12.1, R3.1, R6.1, U1.1 (VCC), U3.1 (OUT), U3.2 (OUT__1), U3.4 (FB)
/5V_TEENSY: C9.1, C10.1, L2.2, U4.1 (FB), U5.5V (VIN)
/BAT_IN: J1.1, J2.1
/LED_STATUS: R7.1, U5.7 (RX2)
/RADIO_BUSY: U1.12 (BUSY), U5.3 (PWM)
/RADIO_DIO1: U1.13 (DI01), U5.4 (PWM)
/RADIO_MISO: U1.3 (MISO_TX), U5.12 (MISO)
/RADIO_MOSI: U1.4 (MOSI_RX), U5.11 (MOSI)
/RADIO_NRESET: U1.11 (NRESET), U5.2 (PWM)
/RADIO_NSS: R3.2, U1.6 (NSS_CTS), U5.10 (CS)
/RADIO_RX_EN: R4.1, U1.8 (RX_EN), U5.5 (PWM)
/RADIO_SCK: U1.5 (SCK_RTSN), U5.13 (SCK)
/RADIO_TX_EN: R5.1, U1.9 (TX_EN), U5.6 (PWM)
/VBAT: C1.1, C7.1, J2.2, U2.2 (EN), U2.3 (IN), U4.2 (EN), U4.3 (IN)
/V_out: C3.1, C4.1, C5.1, L1.2, R1.1, U3.6 (EN), U3.7 (IN), U3.8 (IN__1)
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.2, C12.2, D1.1 (K), D2.1 (K), H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1), J1.2, R2.2, R4.2, R5.2, U1.2 (GND), U1.7 (GND), U1.10 (GND), U1.16 (GND), U2.4 (GND), U3.3 (N/C), U3.5 (GND), U3.9 (EPAD), U4.4 (GND), U5.G (GND), U5.G1 (GND), U5.G2 (GND)
unnamed: D1.2 (A), R6.2
unnamed: D2.2 (A), R7.2
unnamed: C2.1, U2.6 (BST)
unnamed: R1.2, R2.1, U2.1 (FB)
unnamed: C2.2, L1.1, U2.5 (SW)
unnamed: C8.1, U4.6 (BST)
unnamed: C8.2, L2.1, U4.5 (SW)

Notes on the sheet:
Mounting holes
Radio interface
Controller
Power supplies

Board: 2 copper layers, 50.0 x 75.0 mm, 34 parts (0 on the bottom side), 23 nets.

## KiCad design Spaceport/PCBs/Sensor Boards/SensorBoardAirbrake/SensorBoardNoMCU.kicad_pcb

Parts:
C1, C2, C3, C4, C5: 100n; C_0603_1608Metric
D1: PWR; LED_0805_2012Metric
H1, H2: MountingHole; MountingHole_3.2mm_M3
J2: I2C; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
R2, R3: 5k1; R_0603_1608Metric
R4: 560; R_0603_1608Metric
U1: BMI088; PQFN50P450X300X100-16N
U2: MLX90393ELW-ABA-014-RE; QFN-16-1EP_3x3mm_P0.5mm_EP1.75x1.75mm; MPN MLX90393ELW-ABA-014-RE; LCSC Part C1518192
U6: MS5611-01BA; LGA-8_3x5mm_P1.25mm

Connections:
+3.3V: C1.1, C2.1, C3.1, C4.1, C5.1, J2.1, R2.1, R3.1, R4.1, U1.3 (VDD), U1.7 (PS), U1.11 (VDDIO), U1.14 (CSB1), U2.2 (SENB/CS), U2.8 (VDD_IO), U2.12 (A0), U2.15 (VDD), U6.1 (VDD), U6.2 (PS)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D1.1 (K), J2.4, U1.2 (NC), U1.4 (GNDA), U1.6 (GNDIO), U1.10 (SDO2), U1.15 (SDO1), U2.4 (N/C), U2.9 (N/C), U2.10 (N/C), U2.11 (A1), U2.13 (VSS), U2.14 (N/C), U2.16 (N/C), U2.17 (EP), U6.3 (GND), U6.4 (CSB), U6.5 (CSB)
unnamed: D1.2 (A), R4.2
SCL1: J2.3, R3.2, U1.8 (SCL/SCK), U2.3 (SCL/SCLK), U6.8 (SCLK)
SDA1: J2.2, R2.2, U1.9 (SDA/SDI), U2.5 (SDA/MOSI), U6.7 (SDI/SDA)

Notes on the sheet:
IMU
TRT Sensor Board
I2C: Acc: 0x18 Gyr: 0x68
I2C: 0x19
Magnetometer
I2C Header
Mounting Holes
Barometer
I2C: 0x77

Board: 2 copper layers, 18.0 x 27.0 mm, 15 parts (0 on the bottom side), 5 nets.

## KiCad design Spaceport/PCBs/flight-computer/Alternate layout/flight-computer.kicad_pcb

Parts:
BZ1: Buzzer; Buzzer_Murata_PKMCS0909E
C10, C11: 2.2 µF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C12, C13, C14, C15, C17, C19, C21, C23, C27: 100 nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C16: 4.7 µF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D3, D4, D5, D6: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2, H4: MountingHole; MountingHole_3.2mm_M3_DIN965
J1: SWD; PinHeader_1x05_P2.54mm_Vertical
J2, J3, J5: UART; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J7: I2C; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J8: SPI; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
JP1: BOOT; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
NT1: NetTie_2; NetTie-2_SMD_Pad0.5mm
R1, R2, R10, R11: 5.1 kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R7, R8, R9: 110 Ω; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R23: 10 kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R24: 78.7 kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R26: 47 kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R32: 33 Ω; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U7: STM32H723VEHx; TFBGA-100_8x8mm_Layout10x10_P0.8mm
Y1: ECS-2520S; Oscillator_SMD_ECS_2520MV-xxx-xx-4Pin_2.5x2.0mm

Connections:
+3V3A: C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C19.1, C21.1, C27.2, J1.1, JP1.1 (A), R9.1, R10.1, R11.1, U7.B2 (VBAT), U7.D2 (VDD), U7.F4 (VDD), U7.F5 (VDD), U7.F6 (VDD33USB), U7.H1 (VDDA), U7.K1 (VDD), Y1.1 (Tri-State), Y1.4 (VDD); also elsewhere on the board
+3V3B: J2.1, J3.1, J5.1, J7.1, J8.1, R1.1, R2.1; also elsewhere on the board
/BAT_VSENSE: R24.2, R26.1, U7.F3 (PC3_C)
/I2C1_SCL: R11.2, U7.B4 (PB8); also elsewhere on the board
/I2C1_SDA: R10.2, U7.A4 (PB9); also elsewhere on the board
/I2C2_SCL: J7.3, R1.2, U7.J7 (PB10)
/I2C2_SDA: J7.2, R2.2, U7.K7 (PB11)
/INT_HG_IMU_1: U7.A5 (PB7); also elsewhere on the board
/INT_HG_IMU_2: U7.A6 (PB4(NJTRST)); also elsewhere on the board
/INT_IMU_1: U7.A1 (PC14); also elsewhere on the board
/INT_IMU_2: U7.C4 (PE1); also elsewhere on the board
/INT_IMU_3: U7.A3 (PE2); also elsewhere on the board
/INT_IMU_4: U7.A2 (PC13); also elsewhere on the board
/INT_MAG_1: U7.A7 (PB3(JTDO); also elsewhere on the board
/INT_MAG_2: U7.A8 (PA15(JTDI)); also elsewhere on the board
/PYRO_FIRE_1: U7.B6 (PD5); also elsewhere on the board
/PYRO_FIRE_2: U7.B5 (PB6); also elsewhere on the board
/PYRO_SENS_1: U7.F1 (PC0); also elsewhere on the board
/PYRO_SENS_2: U7.F2 (PC1); also elsewhere on the board
/RST: C23.2, J1.5, U7.E1 (NRST)
/SDCard/D0: U7.F9 (PC8); also elsewhere on the board
/SDCard/D1: U7.E9 (PC9); also elsewhere on the board
/SDCard/D2: U7.B9 (PC10); also elsewhere on the board
/SDCard/D3: U7.B8 (PC11); also elsewhere on the board
/SDCard/SCLK: U7.C8 (PC12); also elsewhere on the board
/SDMMC_CMD: U7.B7 (PD2); also elsewhere on the board
/SPI1_CS: J8.5, U7.K2 (PA3)
/SPI1_MISO: J8.3, U7.J3 (PA6)
/SPI1_MOSI: J8.2, U7.K3 (PA7)
/SPI1_SCK: J8.4, U7.H3 (PA5)
/SWD_CLK: J1.2, U7.A9 (PA14(JTCK)
/SWD_DIO: J1.4, U7.A10 (PA13(JTMS)
/TIM3_CH1: R6.1, U7.F10 (PC6)
/TIM3_CH2: R8.1, U7.E10 (PC7)
/TIM12_CH1: BZ1.1 (+), U7.H10 (PB14)
/TIM12_CH2: R7.1, U7.G10 (PB15)
/UART4_RX: J5.3, U7.H2 (PA1)
/UART4_TX: J5.2, U7.G2 (PA0)
/UART5_RX: J2.3, U7.K8 (PB12)
/UART5_TX: J2.2, U7.J8 (PB13)
/UART7_RX: J3.3, U7.H5 (PE7)
/UART7_TX: J3.2, U7.J5 (PE8)
/USB-C_Port/D+: U7.B10 (PA12); also elsewhere on the board
/USB-C_Port/D-: U7.C10 (PA11); also elsewhere on the board
/USB_OTG_ID: U7.D10 (PA10)
GND: BZ1.2 (-), C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C19.2, C21.2, C23.1, C27.1, D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), J1.3, J2.4, J3.4, J5.4, J7.4, J8.6, NT1.2, R24.1, U7.C2 (VSS), U7.E4 (VSS), U7.E5 (VSS), U7.E6 (VSS), U7.G1 (VSSA), U7.J1 (VSS), Y1.2 (GND); also elsewhere on the board
unnamed: C10.1, U7.F8 (VCAP)
unnamed: C11.1, U7.E7 (VCAP)
unnamed: D3.2 (A), R9.2
unnamed: D4.2 (A), R7.2
unnamed: D5.2 (A), R6.2
unnamed: D6.2 (A), R8.2
unnamed: JP1.2 (B), R23.1, U7.D5 (BOOT0)
unnamed: NT1.1, R23.2, U7.F7 (PDR_ON)
unnamed: R32.2, U7.C1 (PH0)
unnamed: R32.1, Y1.3 (OUT)
VBUS: R26.2; also elsewhere on the board

Notes on the sheet:
Summary of MCU Connections: - 3x UART - 1x I2C - 1x SPI - 1x SWD - 1x SDMMC - 1x USB 2.0 - 4x PWM Pins - 2z GPIO Toggle - 3x Analog In - 1x Buzzer - 2x Pyro Channel Fire Pins - 2x Pyro Channel Sense Pins - 3x LED PWM - 1x Voltage sense
VDD Caps
I2C 2
Assuming NRST pin goes to button, datasheet recommends a 0.1uF Capacitor to protect against parisitic resets.
ESR <= 100 mΩ
Boot(pin) = 0 and BOOT_ADD0(optionbyte) = 0x1FF0
VDD33USB Caps ESR <= 600 mΩ
VDDA Caps
LEDS
24MHZ +- 50ppm
110R gives an output current of about 12 mA assuming input PWM votlage amplitude is 3.3V and assuming V_forward is about 2.0 V
SPI 2
Tri State should be high so the chip outputs a clock signal
VBAT Caps
Connectivity Bus Notes: - ALL UART TX/RX, I2C SDA/SCL, SPI MOSI/MISO/SCK will need to be configured for the pin they are connected to in code. Defaults WILL NOT WORK

Parts:
C4, C5: 100 nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
U3: H3LIS331DL; QFN300X300X100-16N

Connections:
+3V3A: C4.1, C5.1, U3.1 (VDD_IO), U3.7 (SDO/SA0), U3.8 (CS), U3.14 (VDD), U3.15 (RESERVED); also elsewhere on the board
/I2C1_SCL: U3.4 (SCL/SPC); also elsewhere on the board
/I2C1_SDA: U3.6 (SDA/SDI/SDO); also elsewhere on the board
/INT_HG_IMU_1: U3.11 (INT1); also elsewhere on the board
/INT_HG_IMU_2: U3.9 (INT2); also elsewhere on the board
GND: C4.2, C5.2, U3.5 (GND), U3.10 (RESERVED), U3.12 (GND), U3.13 (GND), U3.16 (GND); also elsewhere on the board

Notes on the sheet:
0x19
Pull CS high to enable I2C

Parts:
C7: 22 µF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8: 100 nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9, C41, C42, C43, C44: 10 µF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C20: 3.3 nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
IC1, IC2: AP7362-33SP-13; Diodes_SO-8EP; Mouser Part Number 621-AP7362-33SP-13
J6: SCREW_SW; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J9: 3.3VOUT; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J10: BATT; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
L1: 2.2 µH; L_Sumida_CDMC6D28_7.25x6.5mm
R4: 38.3 kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12: 11 kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U4: TPS62130; VQFN-16-1EP_3x3mm_P0.5mm_EP1.68x1.68mm_ThermalVias

Connections:
+3.6V: C7.1, C41.1, C43.1, IC1.2 (EN), IC1.3 (IN_1), IC1.4 (IN_2), IC2.2 (EN), IC2.3 (IN_1), IC2.4 (IN_2), L1.2, R4.1, U4.14 (VOS)
+3V3A: C42.1, IC1.5 (OUT_1), IC1.6 (OUT_2), IC1.7 (OUT_3); also elsewhere on the board
+3V3B: C44.1, IC2.5 (OUT_1), IC2.6 (OUT_2), IC2.7 (OUT_3), J9.1; also elsewhere on the board
GND: C7.2, C8.2, C9.1, C20.2, C41.2, C42.2, C43.2, C44.2, IC1.1 (GND), IC1.9 (EP), IC2.1 (GND), IC2.9 (EP), J6.2, J9.2, R12.2, U4.6 (GND), U4.7 (FSW), U4.8 (DEF), U4.15 (GND), U4.16 (GND), U4.17 (GND); also elsewhere on the board
unnamed: J6.1, J10.2
unnamed: L1.1, U4.1 (SW), U4.2 (SW), U4.3 (SW)
unnamed: R4.2, R12.1, U4.5 (FB)
unnamed: C20.1, U4.9 (SS/TR)
VBUS: C8.1, C9.2, J10.1, U4.10 (VIN), U4.11 (VIN), U4.12 (VIN), U4.13 (EN); also elsewhere on the board

Notes on the sheet:
100 nF must be placed between pins 6 and 10
Buck converter
LDO

Parts:
C6, C28: 100 nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
U10: MLX90393ELW-ABA-xxx-xx; QFN-16-1EP_3x3mm_P0.5mm_EP1.75x1.75mm

Connections:
+3V3A: C6.1, C28.2, U10.2 (CS), U10.8 (Supply), U10.15 (VCC); also elsewhere on the board
/I2C1_SCL: U10.3 (SCLK); also elsewhere on the board
/I2C1_SDA: U10.5 (SDA/MOSI); also elsewhere on the board
/INT_MAG_1: U10.1 (INT); also elsewhere on the board
/INT_MAG_2: U10.7 (INT/TRIG); also elsewhere on the board
GND: C6.2, C28.1, U10.4 (NC), U10.9 (NC), U10.10 (NC), U10.11 (A1), U10.12 (A0), U10.13 (GND), U10.14 (NC), U10.16 (NC), U10.17 (GND); also elsewhere on the board

Notes on the sheet:
0x19

Parts:
C2, C3: 100 nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
U2: BMI088; Bosch_LGA-16_4.5x3mm_P0.5mm_LayoutBorder7x1y_ClockwisePinNu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

Connections:
+3V3A: C2.2, C3.2, U2.3 (VDD), U2.7 (PS), U2.11 (VDDIO), U2.14 (CSB1); also elsewhere on the board
/I2C1_SCL: U2.8 (SCL/SCK); also elsewhere on the board
/I2C1_SDA: U2.9 (SDA/SDI); also elsewhere on the board
/INT_IMU_1: U2.16 (INT1); also elsewhere on the board
/INT_IMU_2: U2.1 (INT2); also elsewhere on the board
/INT_IMU_3: U2.12 (INT3); also elsewhere on the board
/INT_IMU_4: U2.13 (INT4); also elsewhere on the board
GND: C2.1, C3.1, U2.2 (NC), U2.4 (GNDA), U2.6 (GNDIO), U2.10 (SDO2), U2.15 (SDO1); also elsewhere on the board

Notes on the sheet:
accel 0x18 gyro 0x68
Schematic by Jack Yeulenski I2C address accelerometer: 0X18 I2C address gyroscope:0x68

Parts:
D10: D_Schottky; D_SMA
J11: Conn_01x04; TerminalBlock_Phoenix_PT-1,5-4-3.5-H_1x04_P3.50mm_Horizontal
R13, R15: 10 kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14: 8.06 kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16: 9.09 kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17, R20: 3.3 kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R19, R21: 100 Ω; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R22, R27: 100 kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R25, R28: 27 kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U6: LM393; SOIC-8_3.9x4.9mm_P1.27mm
U8: Si7232DN; Vishay_PowerPAK_1212-8_Dual

Connections:
+3V3A: R15.1, U6.8 (V+); also elsewhere on the board
/PYRO_FIRE_1: R17.1, R19.1; also elsewhere on the board
/PYRO_FIRE_2: R20.1, R21.1; also elsewhere on the board
/PYRO_SENS_1: R22.2, R25.1; also elsewhere on the board
/PYRO_SENS_2: R27.2, R28.1; also elsewhere on the board
/Pyros/FET_1: J11.4, R22.1, U8.6 (D)
/Pyros/FET_2: J11.2, R27.1, U8.5 (D)
/Pyros/PYRO_POWER: D10.1 (K), J11.1, J11.3, R13.1
GND: R14.2, R16.2, R17.2, R20.2, R25.2, R28.2, U6.4 (V-), U8.1 (S), U8.3 (S); also elsewhere on the board
unnamed: R13.2, R14.1, U6.3 (+), U6.5 (+)
unnamed: R15.2, R16.1, U6.2 (-), U6.6 (-)
unnamed: R19.2, U6.1, U8.2 (G)
unnamed: R21.2, U6.7, U8.4 (G)
VBUS: D10.2 (A); also elsewhere on the board

Parts:
D2: ESDA5V3L; SOT-23-3
D9: D_Schottky; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J4: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R5, R18: 5.1 kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
/USB-C_Port/D+: D2.1 (K), J4.A6 (D+), J4.B6 (D+); also elsewhere on the board
/USB-C_Port/D-: D2.2 (K), J4.A7 (D-), J4.B7 (D-); also elsewhere on the board
GND: D2.3 (A), J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.S1 (SHIELD), R5.1, R18.1; also elsewhere on the board
unnamed: D9.2 (A), J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS)
unnamed: J4.A5 (CC1), R18.2
unnamed: J4.B5 (CC2), R5.2
VBUS: D9.1 (K); also elsewhere on the board

Parts:
J14: Micro_SD_Card; microSD_HC_Wuerth_693072010801
R3, R29, R30, R31: 10 kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
+3V3A: J14.4 (VDD); also elsewhere on the board
/SDCard/D0: R29.2; also elsewhere on the board
/SDCard/D1: R3.2; also elsewhere on the board
/SDCard/D2: R31.1; also elsewhere on the board
/SDCard/D3: R30.1; also elsewhere on the board
/SDCard/SCLK: J14.5 (CLK); also elsewhere on the board
/SDMMC_CMD: J14.3 (CMD); also elsewhere on the board
GND: J14.6 (VSS), J14.9 (SHIELD); also elsewhere on the board
unnamed: J14.7 (DAT0), R29.1
unnamed: J14.8 (DAT1), R3.1
unnamed: J14.1 (DAT2), R31.2
unnamed: J14.2 (DAT3/CD), R30.2

Schematic: GPS.kicad_sc.kicad_sch

Parts:
C18, C24: 100 nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
U5: SAM-M10Q-00B; XCVR_SAM-M10Q-00B; PARTREV R03

Connections:
+3V3A: C18.1, C24.1, U5.2 (V_IO), U5.3 (V_BCKP), U5.17 (VCC); also elsewhere on the board
/I2C1_SCL: U5.12 (SCL); also elsewhere on the board
/I2C1_SDA: U5.9 (SDA); also elsewhere on the board
GND: C18.2, C24.2, U5.1 (GND), U5.4 (GND__1), U5.5 (GND__2), U5.6 (GND__3), U5.10 (GND__4), U5.11 (GND__5), U5.15 (GND__6), U5.16 (GND__7), U5.20 (GND__8); also elsewhere on the board

Notes on the sheet:
SAM-M10Q operates at I²C address 0x42 (fixed).
